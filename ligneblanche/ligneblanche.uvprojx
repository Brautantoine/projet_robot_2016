# Keil uVision project ligneblanche.uvprojx, settings and files
target ligneblanche (ARM-ADS)
  device: STM32F303K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: ligneblanche
  c flags: Optim=2 uC99=1
  c misc: -DDEVICE_RTC=1 -DMBED_BUILD_TIMESTAMP=1480577160.27 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DDEVICE_PWMOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_CORTEX_M -DTARGET_NUCLEO_F303K8 -DARM_MATH_CM4 -DDEVICE_I2C=1 -DDEVICE_PORTIN=1 -DTARGET_STM32F303K8 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DTARGET_STM -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_RTC_LSI=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM -DTARGET_STM32F3
  c include: .; IHM; mbed/.; mbed/TARGET_NUCLEO_F303K8; mbed/TARGET_NUCLEO_F303K8/TARGET_STM; mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3; mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8; mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8/device; mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/device; mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-D__FPU_PRESENT=1,-DDEVICE_RTC_LSI=1,-DARM_MATH_CM4,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_STD/stm32f303x8.sct
  group IHM
    IHM/: all_includes.h ident.h IHM.cpp IHM.h ktypes.h
  group TARGET_NUCLEO_F303K8
    mbed/TARGET_NUCLEO_F303K8/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8/: objects.h PeripheralNames.h PinNames.h PortNames.h
  group TARGET_STM
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/: mbed_rtx.h
  group TARGET_STM32F3
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/: common_objects.h device.h gpio_object.h PeripheralPins.h rtc_api_hal.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o hal_tick.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32f303x8.o stm32f3xx_hal.o stm32f3xx_hal_adc.o stm32f3xx_hal_adc_ex.o stm32f3xx_hal_can.o stm32f3xx_hal_cec.o stm32f3xx_hal_comp.o stm32f3xx_hal_cortex.o stm32f3xx_hal_crc.o stm32f3xx_hal_crc_ex.o stm32f3xx_hal_dac.o stm32f3xx_hal_dac_ex.o stm32f3xx_hal_dma.o stm32f3xx_hal_flash.o stm32f3xx_hal_flash_ex.o stm32f3xx_hal_gpio.o stm32f3xx_hal_hrtim.o stm32f3xx_hal_i2c.o stm32f3xx_hal_i2c_ex.o stm32f3xx_hal_i2s.o stm32f3xx_hal_i2s_ex.o stm32f3xx_hal_irda.o stm32f3xx_hal_iwdg.o stm32f3xx_hal_nand.o stm32f3xx_hal_nor.o stm32f3xx_hal_opamp.o stm32f3xx_hal_opamp_ex.o stm32f3xx_hal_pccard.o stm32f3xx_hal_pcd.o stm32f3xx_hal_pcd_ex.o stm32f3xx_hal_pwr.o stm32f3xx_hal_pwr_ex.o stm32f3xx_hal_rcc.o stm32f3xx_hal_rcc_ex.o stm32f3xx_hal_rtc.o stm32f3xx_hal_rtc_ex.o stm32f3xx_hal_sdadc.o stm32f3xx_hal_smartcard.o stm32f3xx_hal_smartcard_ex.o stm32f3xx_hal_smbus.o stm32f3xx_hal_spi.o stm32f3xx_hal_spi_ex.o stm32f3xx_hal_sram.o stm32f3xx_hal_tim.o stm32f3xx_hal_tim_ex.o stm32f3xx_hal_tsc.o stm32f3xx_hal_uart.o stm32f3xx_hal_uart_ex.o stm32f3xx_hal_usart.o stm32f3xx_hal_wwdg.o stm32f3xx_ll_fmc.o stm_spi_api.o sys.o system_stm32f3xx.o trng_api.o us_ticker.o
  group device
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f303x8.h stm32f3xx.h system_stm32f3xx.h
    mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/device/: stm32_hal_legacy.h stm32f3xx_hal.h stm32f3xx_hal_adc.h stm32f3xx_hal_adc_ex.h stm32f3xx_hal_can.h stm32f3xx_hal_cec.h stm32f3xx_hal_comp.h stm32f3xx_hal_comp_ex.h stm32f3xx_hal_conf.h stm32f3xx_hal_cortex.h stm32f3xx_hal_crc.h stm32f3xx_hal_crc_ex.h stm32f3xx_hal_dac.h stm32f3xx_hal_dac_ex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_hrtim.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_i2s.h stm32f3xx_hal_i2s_ex.h stm32f3xx_hal_irda.h stm32f3xx_hal_irda_ex.h stm32f3xx_hal_iwdg.h stm32f3xx_hal_nand.h stm32f3xx_hal_nor.h stm32f3xx_hal_opamp.h stm32f3xx_hal_opamp_ex.h stm32f3xx_hal_pccard.h stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_rtc.h stm32f3xx_hal_rtc_ex.h stm32f3xx_hal_sdadc.h stm32f3xx_hal_smartcard.h stm32f3xx_hal_smartcard_ex.h stm32f3xx_hal_smbus.h stm32f3xx_hal_spi.h stm32f3xx_hal_spi_ex.h stm32f3xx_hal_sram.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h stm32f3xx_hal_tsc.h stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.h stm32f3xx_hal_usart.h stm32f3xx_hal_usart_ex.h stm32f3xx_hal_wwdg.h stm32f3xx_ll_fmc.h
  group drivers
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
  group hal
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
  group ligneblanche
    ./: main.cpp mbed_config.h nboard.h
  group mbed
    mbed/: mbed.h
  group platform
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_stats.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
